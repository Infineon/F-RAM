# Keil uVision project spi_fram.uvprojx, settings and files
target spi_fram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_fram
  AfterMake: fromelf --bin --output bin\spi_fram.bin bin\spi_fram.axf
  AfterMake: fromelf -cedrst --output bin\spi_fram.txt bin\spi_fram.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO2 keil
  c include: ../src;../../../bsp;../../../../..;../../../../../utils;../../../../../devices;../../../../../mcu/apollo2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\spi_fram.sct
  link misc: ../../../../../mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: main.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../devices/: am_devices_spifram.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo2/hal/keil/bin/: libam_hal.lib
